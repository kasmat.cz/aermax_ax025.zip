Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: HVAC_Air-Conditioning_Apen-Group-S-P-A_Aerotermi-AX025.ifc
Time: 2019-04-26T07:24:32
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFlowTerminal: Aerotermi AX025
ePset_BIMobjectScript - LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Aerotermi AX025; SKU (BO_prodsku): AX025; ManufacturName (BO_Manufac): Apen Group; BrandUrl (BO_brandurl): http://www.apengroup.com/en/; ProductFamily (BO_prodfam): Air heaters; ProductGroup (BO_prodgroup): AX; ManufacturCountry (BO_mancont): Italy; DesignCountry (BO_designcont): Italy; PublishDate (BO_publisdat): 3/27/2019; EditionNumber (BO_edinum): 1; Width (BO_width): 765; Height (BO_height): 730; Depth (BO_depth): 595; Weight (BO_weight): 22; QR (BO_boqrurl): http://bimobject.com/apengroup/product/AX025; ProductDataUrl (BO_prodaturl): bimobject.com/apengroup/product/AX025; ProductUrl (BO_producturl): http://www.apengroup.com/en/industry-and-tertiary-sector/aermax-ax-water-fan-units/; TechnicalDescription (BO_techcert): http://www.apengroup.com/en/industry-and-tertiary-sector/aermax-ax-water-fan-units/; MaterialMain (BO_mainmat): Copper; MaterialSecondary (BO_secmat): Aluminium; BimObjectMainCategory (BO_bomaincat): HVAC; BimObjectMainCategoryCode (BO_bomaincat_code): hvac; BimObjectCategory (BO_bocat): Air Conditioning; BimObjectCategoryCode (BO_bocat_code): hvac-air-con; IfcClassification (BO_ifcclas): Air Terminal; UnspcCode (BO_unspc): 40101701; Uniclass14Code (BO_uniclass_1_4_code): L7531; Uniclass14Description (BO_uniclass_1_4_desc): HVAC circulation pumps; Uniclass20Code (BO_uniclass_2_0_code): PR-60-38-02; Uniclass20Description (BO_uniclass_2_0_desc): Air To Air Heat Pumps; Uniclass2015Code (BO_uniclass2015_code): EF_65_80; Uniclass2015Description (BO_uniclass2015_desc): Air conditioning; NBSReference (BO_nbs_ref): 03-03; NBSReferenceDescription (BO_nbs_desc): Air Conditioning Units; OmniClassCode (BO_omniclass_code): 23-33 15 17 17; OmniClassDescription (BO_omniclass_name): Fuel Fired HVAC Air Heaters; MasterFormat2014Code (BO_masterformat2014_code): 23 00 00; MasterFormat2014Description (BO_masterformat2014_name): Heating, Ventilating, and Air Conditioning (HVAC); UniFormat2Code (BO_uniformat2_code): D30; UniFormat2Description (BO_uniformat2_name): HVAC; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionSouthAmerica (BO_southamerica): AR, BO, BR, CL, CO, EC, FK, GF, GY, PE, PY, SR, UY, VE; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU; RegionAfrica (BO_africa): AO, BF, BI, BJ, BW, CD, CF, CG, CI, CM, CV, DJ, DZ, EH, ER, ET, GA, GH, GM, GN, GQ, GW, KE, KM, LR, LS, LY, MA, MG, ML, MR, MU, MW, MZ, NA, NE, NG, RE, RW, SC, SD, SH, SL, SN, SO, SS, ST, SZ, TD, TG, TN, TZ, UG, YT, ZA, ZM, ZW; RegionAntarctica (BO_antarctica): AQ, BV, GS, HM, TF
